<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PI_try_1.ewp</path>
  </project>
  <batchBuild />
</workspace>
